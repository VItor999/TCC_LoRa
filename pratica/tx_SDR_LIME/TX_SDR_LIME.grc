options:
  parameters:
    generate_options: no_gui
    id: TX_SDR_LIME
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: bw
  id: parameter
  parameters:
    label: bw
    type: intx
    value: '125000'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: 915e6
    type: intx
    value: '915000000'
  states: {}
- name: cr
  id: parameter
  parameters:
    label: cr
    type: intx
    value: '1'
  states: {}
- name: has_crc
  id: parameter
  parameters:
    label: has_crc
    type: intx
    value: '1'
  states: {}
- name: impl_head
  id: parameter
  parameters:
    label: impl_head
    type: intx
    value: '0'
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: in_file
    type: str
    value: /home/vcarv/TCC/simulation/tx_data/tx_text.txt
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: center_freq
    samp_rate: samp_rate
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: bool(has_crc)
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: bool(has_crc)
    impl_head: bool(impl_head)
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    minoutbuf: '10000000'
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8,16]'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    separator: ''','''
    source_type: file_source
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '250000'
  states: {}
- name: sf
  id: parameter
  parameters:
    label: sf
    type: intx
    value: '9'
  states: {}
- name: soft_decoding
  id: parameter
  parameters:
    label: soft_decoding
    type: intx
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: samples
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: input_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: samples
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: input_data
  states: {}

connections:
- [blocks_file_source_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', virtual_sink_2_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', virtual_sink_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', virtual_sink_1, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [virtual_source_0, '0', lora_sdr_interleaver_0, '0']
- [virtual_source_1, '0', limesdr_sink_0, '0']
- [virtual_source_1_0, '0', lora_sdr_whitening_0, '0']

metadata:
  file_format: 1
