options:
  parameters:
    generate_options: no_gui
    id: RX_LIME
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: out_file
  id: variable
  parameters:
    value: '''/home/vcarv/TCC/pratica/rx_data/1/rx_7_125000/pqp.dat'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate_rtl
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(has_crc)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    oversample: '0'
    rf_freq: center_freq
    samp_rate: samp_rate_rtl
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: 'False'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_1
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_header: 'False'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '5'
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:54321
    timeout: '1000'
    type: byte
  states: {}

connections:
- [blocks_selector_0, '0', zeromq_pub_sink_0, '0']
- [limesdr_source_0, '0', rational_resampler_xxx_0, '0']
- [lora_sdr_crc_verif_0_0, '0', blocks_selector_0, '1']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', blocks_selector_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_1, '0']
- [lora_sdr_header_decoder_1, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_1, frame_info, lora_sdr_frame_sync_0, frame_info]
- [rational_resampler_xxx_0, '0', lora_sdr_frame_sync_0, '0']

metadata:
  file_format: 1
