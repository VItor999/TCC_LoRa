options:
  parameters:
    author: Vitor Carvalho
    description: GNURadio flowchart to recieve LoRa messages using RTL-SDR and send the recieved messages via socket.
    generate_options: no_gui
    id: RX_RTL
    output_language: python
    run_options: run
    title: RX_RTL
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate_rtl
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out_file
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: out_file
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(has_crc)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: bw
  id: parameter
  parameters:
    label: bw
    type: intx
    value: '125000'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: 915e6
    type: intx
    value: '915000000'
  states: {}
- name: cr
  id: parameter
  parameters:
    label: cr
    type: intx
    value: '1'
  states: {}
- name: has_crc
  id: parameter
  parameters:
    label: has_crc
    type: intx
    value: '1'
  states: {}
- name: impl_head
  id: parameter
  parameters:
    label: impl_head
    type: intx
    value: '0'
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: 'False'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_1
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_header: 'False'
  states: {}
- name: out_file
  id: parameter
  parameters:
    label: out_file
    type: str
    value: /home/vcarv/TCC/practice/rx_SDR_tx_SDR/pqp.dat
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '5'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 915e6
    gain0: '28'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_rtl
    sync: sync
    type: fc32
  states: {}
- name: samp_rate_0
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '250000'
  states: {}
- name: sf
  id: parameter
  parameters:
    label: sf
    type: intx
    value: '9'
  states: {}
- name: soft_decoding
  id: parameter
  parameters:
    label: soft_decoding
    type: intx
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: out_data
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: out_data_validated
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: raw_bin_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: out_data
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: out_data_validated
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: raw_bin_data
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:54321
    timeout: '1000'
    type: byte
  states: {}

connections:
- [blocks_selector_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_0, '0', blocks_file_sink_1, '0']
- [blocks_selector_0, '0', zeromq_pub_sink_0, '0']
- [lora_sdr_crc_verif_0_0, '0', virtual_sink_0_0_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_dewhitening_0, '0', virtual_sink_0_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', virtual_sink_1, '0']
- [lora_sdr_header_decoder_1, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_1, frame_info, lora_sdr_frame_sync_0, frame_info]
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', lora_sdr_frame_sync_0, '0']
- [virtual_source_0_0, '0', blocks_selector_0, '0']
- [virtual_source_0_0_0, '0', blocks_selector_0, '1']
- [virtual_source_1, '0', lora_sdr_header_decoder_1, '0']

metadata:
  file_format: 1
