options:
  parameters:
    author: vcarv
    generate_options: no_gui
    id: TX_RX_SIM
    output_language: python
    run_options: run
  states: {}

blocks:
- name: taps
  id: variable
  parameters:
    value: '[complex(tap) for tap in taps_str]'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: out_file
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: has_crc
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: bw
  id: parameter
  parameters:
    label: bw
    type: intx
    value: '125000'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: 915e6
    type: intx
    value: '915000000'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: noise_seed
    taps: taps
  states: {}
- name: cr
  id: parameter
  parameters:
    label: cr
    type: intx
    value: '1'
  states: {}
- name: has_crc
  id: parameter
  parameters:
    label: has_crc
    type: intx
    value: '1'
  states: {}
- name: impl_head
  id: parameter
  parameters:
    label: impl_head
    type: intx
    value: '0'
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: in_file
    type: str
    value: /home/vcarv/TCC/test/tx_data/tx_text.txt
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: bool(has_crc)
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: 'False'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: bool(soft_decoding)
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: bool(has_crc)
    impl_head: bool(impl_head)
  states: {}
- name: lora_sdr_header_decoder_1
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: bool(impl_head)
    ldro: '0'
    pay_len: '255'
    print_header: 'False'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    minoutbuf: '10000000'
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8,16]'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    separator: ''','''
    source_type: file_source
  states: {}
- name: noise
  id: parameter
  parameters:
    label: noise
    type: eng_float
    value: '0'
  states: {}
- name: noise_seed
  id: parameter
  parameters:
    label: noise_seed
    type: intx
    value: '42'
  states: {}
- name: out_file
  id: parameter
  parameters:
    label: out_file
    type: str
    value: /home/vcarv/TCC/test/rx_noise_0.dat
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '250000'
  states: {}
- name: sf
  id: parameter
  parameters:
    label: sf
    type: intx
    value: '7'
  states: {}
- name: soft_decoding
  id: parameter
  parameters:
    label: soft_decoding
    type: intx
    value: '0'
  states: {}
- name: taps_str
  id: parameter
  parameters:
    label: taps_srt
    value: '[''1.0+0.0j'']'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: frame_info_d
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx_data
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: rx_data
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: input_data
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: out_data_validated
  states: {}
- name: virtual_sink_2_1_0
  id: virtual_sink
  parameters:
    stream_id: out_data
  states: {}
- name: virtual_sink_2_2
  id: virtual_sink
  parameters:
    stream_id: raw_bin_data
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx_data
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: input_data
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: out_data_validated
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: out_data
  states: {}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    stream_id: raw_bin_data
  states: {}
- name: virtual_source_1_2_0
  id: virtual_source
  parameters:
    stream_id: frame_info_d
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: rx_data
  states: {}

connections:
- [blocks_file_source_1, '0', blocks_throttle_0, '0']
- [blocks_selector_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_2_0, '0']
- [channels_channel_model_0, '0', virtual_sink_2, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, '0', virtual_sink_2_1, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0, '0', virtual_sink_2_1_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', virtual_sink_2_2, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_1, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_1, frame_info, virtual_sink_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', virtual_sink_1, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_1_0, '0', lora_sdr_whitening_0, '0']
- [virtual_source_1_1, '0', blocks_selector_0, '1']
- [virtual_source_1_1_0, '0', blocks_selector_0, '0']
- [virtual_source_1_2, '0', lora_sdr_header_decoder_1, '0']
- [virtual_source_1_2_0, '0', lora_sdr_frame_sync_0, frame_info]
- [virtual_source_2, '0', lora_sdr_frame_sync_0, '0']

metadata:
  file_format: 1
